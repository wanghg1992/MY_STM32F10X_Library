# Keil uVision project STM32F10X_Library.uvproj, settings and files
target STM32F103X_Library (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F10X_Library
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Drive\exit;..\Drive\led;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\MY_Libraries\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f10x_hd.s
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group FWLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_can.c
  group MY_Libraries
    ../MY_Libraries/src/: MY_STM32F10X_ADC.c MY_STM32F10X_Clock.c MY_STM32F10X_DMA.c MY_STM32F10X_ExInterrupt.c MY_STM32F10X_GPIO.c MY_STM32F10X_NVIC.c MY_STM32F10X_PWM.c MY_STM32F10X_RTC.c MY_STM32F10X_Timer.c MY_STM32F10X_USART.c MY_STM32F10X_SPI.c MY_STM32F10X_IIC.c MY_STM32F10X_SCCB.c MY_STM32F10X_SysTick.c MY_STM32F10X_CAN.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
